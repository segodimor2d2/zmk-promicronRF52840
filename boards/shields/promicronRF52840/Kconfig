## boards/shields/promicronRF52840/Kconfig
```kconfig
config SHIELD_PROMICRONRF52840
    bool "Pro Micro nRF52840 shield"
    depends on BOARD_ADAFRUIT_NRF52840_FEATHER
```
